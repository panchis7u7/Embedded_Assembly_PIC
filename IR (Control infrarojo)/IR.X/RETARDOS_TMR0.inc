RETARDO_1686MICROS_16:
    BCF INTCON,T0IF
    MOVLW D'45'
    MOVWF TMR0
 RETARDO_1686MICROS_16_0:
    BTFSS INTCON,T0IF
    GOTO RETARDO_1686MICROS_16_0
    RETURN
    
 RETARDO_562MICROS_16:
    BCF INTCON,T0IF
    MOVLW D'186'
    MOVWF TMR0
 RETARDO_562MICROS_16_0:
    BTFSS INTCON,T0IF
    GOTO RETARDO_562MICROS_16_0
    RETURN
    
 RETARDO_4500MICROS_16:
    BSF STATUS,RP0
    MOVLW B'11010110'
    MOVWF OPTION_REG
    BCF STATUS,RP0
    BCF STATUS,RP0
    BCF INTCON,T0IF
    MOVLW D'115'
    MOVWF TMR0
 RETARDO_4500MICROS_16_0:
    BTFSS INTCON,T0IF
    GOTO RETARDO_4500MICROS_16_0
    RETURN


